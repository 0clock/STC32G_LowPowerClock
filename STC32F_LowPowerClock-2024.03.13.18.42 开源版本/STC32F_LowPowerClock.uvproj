# Keil uVision project STC32F_LowPowerClock.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32F12K64 Series STC
  cpu: IRAM(0-0x1FFF) XRAM(0x10000-0x10FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: STC32F_LowPowerClock +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: ADC.c BH1745.c BMC050.c CompassMenu.c DATA.c flag.c IIC.c INS5699S.c IO.c logic.c main.c Main_Menu.c OLED.c SecondaryMenu.c SHT41.c SPL06.c ThreeMenu.c time.c Time_Interruption.c TV_Mode.c UART1.c UI.c isr.asm STC32_FPMU_LARGE_V1.0.LIB STC32_MDU32_LARGE_V1.1.LIB SleepMode.c FlashLight.c A重要事项.txt
