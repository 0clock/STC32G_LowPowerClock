# Keil uVision project STC32.uvproj, settings and files
target STC32F12K54 (MCS-251)
  device: STC32F12K54 Series STC
  cpu: IRAM(0-0x1FFF) XRAM(0x10000-0x10FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: STC32_LowPowerClock +hex
  link misc: REMOVEUNUSED
  group Code
    ./Code/: 放置用户代码.txt buzzer.c buzzer.h myoled.c myoled.h BMP.c bms.c bms.h iic.c ins5699s.c task.c gui.c button.c button.h
  group DmxDevice
    ./DmxLibraries/DmxDevice/: dmx_all.h dmx_font.c dmx_font.h dmx_function.c dmx_function.h dmx_icm20602.c dmx_icm20602.h dmx_icm42688.c dmx_icm42688.h dmx_ips.c dmx_ips.h dmx_mpu.c dmx_mpu.h dmx_oled.c dmx_oled.h dmx_tft180.c dmx_tft180.h dmx_tof400c.c dmx_tof400c.h dmx_tsl1401.c dmx_tsl1401.h
  group DmxDriver
    ./DmxLibraries/DmxDriver/: dmx_adc.c dmx_adc.h dmx_board.c dmx_board.h dmx_delay.c dmx_delay.h dmx_eeprom.c dmx_eeprom.h dmx_encoder.c dmx_encoder.h dmx_exti.c dmx_exti.h dmx_gpio.c dmx_gpio.h dmx_hard_spi.c dmx_hard_spi.h dmx_pit.c dmx_pit.h dmx_pwm.c dmx_pwm.h dmx_uart.c dmx_uart.h
    ./DmxLibraries/: STC32_FPMU_LARGE_V1.0.LIB
  group User
    ./User/: isr.c isr.h main.c main.h
