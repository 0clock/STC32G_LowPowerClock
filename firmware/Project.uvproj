# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32F12K54 Series STC
  cpu: IRAM(0-0x1FFF) XRAM(0x10000-0x10FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: Project
  group lib
    ./lib/: STC32F.h STC32G.h time.c
  group devices
    ./device/oled/: oled_ssd13063.c oled_ssd13063.h
  group src
    ./src/: main.c headfile.h
